Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 8dca99f9-ddae-4d82-bd13-67e4f511fcfb, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: Vitra-Storage_Partition-Dacing_Wall_2_rfa.ifc
Time: 2025-11-24T00:57:17+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBuildingElementProxy: Vitra-Storage_Partition-Dacing_Wall_2_rfa:Dancing Wall 2, Vitra-Storage_Partition-Dacing_Wall_2_rfa:Dancing Wall 2:62576
In: Level 1
Type - Material: Basic dark powder-coated 30, 72 Natural Spruce
Type - Other - Category: Specialty Equipment; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Storage_Partition-Dacing_Wall_2_rfa; Features: Diverse combinations; Finish: n/a; Grade: n/a; Material: Metal, spruce and textile.; ModelNumber: n/a; ModelReference: n/a; Name: Dancing_Wall_2_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 1650x500x1906 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 0 mm
Type - Construction - CabinetAsym: Accessories : Cabinet element asymmetrical doors on one side; CabinetSymBoth: Accessories : Cabinet element symmetrical doors on both sides; CabinetSymOne: Accessories : Cabinet element symmetrical doors on one side; CoatRail: Accessories : Coat rail; ElectrificationChannel: Accessories : Electrification channel; ElectrificationChannel3: Accessories : Electrification channel with triple socket; MonitorMount: Accessories : Monitor mount; NotIncluded: Accessories : Not Included; Planter: Accessories : Planters; RecyclingAsym: Accessories : Recycling station asymmetrical; RecyclingSym: Accessories : Recycling station symmetrical; ShelfAsym: Accessories : Shelf asymmetrical; ShelfSym: Accessories : Shelf symmetrical
Type - General - Author: BIMStone; BIMObjectName: Vitra-Storage_Partition-Dancing_Wall_2_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Panel partitions; NBSReference: 45-35-80/420; ProductInformation: The basic function of Dancing Wall is that of a mobile partition that can be used to flexibly divide offices into zones, while providing vertical work space.; Revision: n/a; Uniclass2: Pr_25_71_57_60; Uniclass2015Description: Partition panels; Uniclass2015Reference: Pr_25_71_57_60; Version: 1; VersionDate: 10/11/2025
Type - Identity Data - Collection: Dancing Wall; Cost: 0; Designer: Stephan Hurlemann; Manufacturer: Vitra; Model: Dancing Wall 2; OmniClass Number: 23.25.40.00; Type Name: Dancing Wall 2; URL: https://www.vitra.com/en-us/office/product/details/dancing-wall
Type - Materials and Finishes - PanelWhiteboardMaterial: Cream White
Type - Pset_ElementShading - Color: Black
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Dancing_Wall_2_rfa
Pset_BuildingElementProxyCommon - Reference: Dancing Wall 2; sets with these values: 2
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Storage_Partition-Dacing_Wall_2_rfa; Family and Type: Vitra-Storage_Partition-Dacing_Wall_2_rfa: Dancing Wall 2; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Dancing Wall 2; Type Id: 62560; WarrantyStartDate: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm; Pos A(front left): Panels : Not provided; Pos B (front right): Panels : Not provided; Pos C (rear left): Panels : Not provided; Pos D (rear right): Panels : Not provided; Single elements (pos.1 bottom): Accessories : Not Included; Single elements (pos.1 bottom) Availability: Accessories : Not Included; Single elements (pos.2): Accessories : Not Included; Single elements (pos.2) Availability: Accessories : Not Included; Single elements (pos.3): Accessories : Not Included; Single elements (pos.3) Availability: Accessories : Not Included; Single elements (pos.4 top): Accessories : Not Included; Single elements (pos.4 top) Availability: Accessories : Not Included
Construction - Pos1Available: 0; Pos1SelectorInt: 0; Pos2Available: 0; Pos2SelectorInt: 0; Pos3Available: 0; Pos3SelectorInt: 0; Pos4Available: 0; Pos4SelectorInt: 0
Dimensions - Area: 5.0853 m2; Volume: 1.7166 m3
Materials and Finishes - PanelFourMaterial: Parchment cream white; PanelOneMaterial: Cream white sierra grey; PanelThreeMaterial: Parchment cream white; PanelTwoMaterial: Cream white sierra grey; WallPanelMainMaterial: Basic dark powder-coated 30; WallPanelSecondaryMaterial: 72 Natural Spruce; WallPanelTertiaryMaterial: Black Plastic
Phasing - Phase Created: New Construction
